# Keil uVision project Tx_SecureLEDToggle_TrustZone_S.uvprojx, settings and files
target Tx_SecureLEDToggle_TrustZone_S (6210000::V6.21::ARMCLANG)
  device: STM32N657X0HxQ STMicroelectronics
  pack: Keil.STM32N6xx_DFP.1.0.0
  cpu: IRAM(0x00000000,0x00040000) IRAM2(0x20000000,0x00040000) XRAM(0x24000000,0x3E0000) XRAM2(0x25000000,0x01000000) XRAM3(0x28000000,0x00008000) CPUTYPE("Cortex-M55") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: Tx_SecureLEDToggle_TrustZone_S
  AfterMake: fromelf #L --bincombined --output=$L@L.bin
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32N657xx,USE_HAL_DRIVER, DATATYPE, NO_OTP_FUSE
  c include: ../../AppliSecure/Inc;..\..\..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32N6xx\Include;..\..\..\..\..\..\..\Drivers\STM32N6xx_HAL_Driver\Inc;..\..\..\..\..\..\..\Drivers\BSP\STM32N6xx_Nucleo;../../Secure_nsclib
  library: MicroLIB
  memory RVCT4: ROM 0x34000400 size 0x63c00
  memory RVCT6: RAM 0x24000000 size 0x3e0000
  memory RVCT7: RAM 0x25000000 size 0x1000000
  memory RVCT8: RAM 0x28000000 size 0x8000
  memory RVCT9: RAM 0x34064000 size 0x9c000
  memory RVCT10: RAM 0x20000000 size 0x40000
  scatter file: .\Tx_SecureLEDToggle_TrustZone_S.sct
  link misc: --import_cmse_lib_out=./../../Secure_nsclib/secure_nsclib.o

--diag_suppress L6848W
  group Application/MDK-ARM
    ./: startup_stm32n657xx.c
  group Application/User/Secure
    ../../AppliSecure/Src/: main.c secure_nsc.c stm32n6xx_it.c
  group Drivers/CMSIS
    ../../AppliSecure/Src/: system_stm32n6xx_s.c
  group Drivers/STM32N6xx_HAL_Drivers
    ../../../../../../../Drivers/STM32N6xx_HAL_Driver/Src/: stm32n6xx_hal.c stm32n6xx_hal_cortex.c stm32n6xx_hal_gpio.c stm32n6xx_hal_pwr.c stm32n6xx_hal_pwr_ex.c stm32n6xx_hal_rif.c

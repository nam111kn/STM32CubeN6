<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\FSBL\FSBL.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\AppliSecure\Tx_SecureLEDToggle_TrustZone_s.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\AppliNonSecure\Tx_SecureLEDToggle_TrustZone_ns.ewp</path>
    </project>
    <batchBuild />
</workspace>

# IAR project Ux_Device_Audio_2.0_Standalone.ewp, settings and files
configuration Ux_Device_Audio_2.0_Standalone (ARM, debug)
  General.OGChipSelectEditMenu: STM32N6570-DK ST STM32N6570-DK
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 63
  General.FPU2: 7
  ICCARM.CCDefines: UX_INCLUDE_USER_DEFINE_FILE; STM32N657xx; USE_FULL_LL_DRIVER; USE_HAL_DRIVER; _SNK; USE_AUDIO_CODEC_WM8904
  ICCARM.CCIncludePath2: ../Core/Inc; ../AZURE_RTOS/App; ../USBX/App; ../USBX/Target; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Drivers/CMSIS/Device/ST/STM32N6xx/Include; ../../../../../../Drivers/STM32N6xx_HAL_Driver/Inc; ../../../../../../Drivers/BSP/STM32N6570-DK; ..\..\..\..\..\..\Drivers\BSP\Components\cs42l51; ../../../../../../Drivers/BSP/Components/tcpp0203; ..\..\..\..\..\..\Drivers\BSP\Components\wm8904; ../../../../../../Middlewares/ST/usbx/common/core/inc/; ../../../../../../Middlewares/ST/usbx/ports/generic/inc/; ../../../../../../Middlewares/ST/usbx/common/usbx_stm32_device_controllers/; ../../../../../../Middlewares/ST/usbx/common/usbx_device_classes/inc/
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: TX_SINGLE_MODE_SECURE
  OBJCOPY.OOCOutputFile: Ux_Device_Audio_2.0_Standalone.bin
  ILINK.IlinkOutputFile: Ux_Device_Audio_2.0_Standalone.out
  ILINK.IlinkIcfFile: stm32n657xx_axisram2_fsbl.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32n657xx_fsbl.s
  group Application/User/Core
    ../Core/Src/: main.c stm32n6xx_hal_msp.c stm32n6xx_it.c
  group Application/User/USBX/App
    ../USBX/App/: app_usbx_device.c ux_device_audio.c ux_device_audio_play.c ux_device_descriptors.c
  group Doc
    ../: README.md
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/tcpp0203/: tcpp0203.c tcpp0203_reg.c
    ../../../../../../Drivers/BSP/Components/wm8904/: wm8904.c wm8904_reg.c
  group Drivers/BSP/STM32N6570-DK
    ../../../../../../Drivers/BSP/STM32N6570-DK/: stm32n6570_discovery.c stm32n6570_discovery_audio.c stm32n6570_discovery_bus.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32n6xx_fsbl.c
  group Drivers/STM32N6xx_HAL_Driver
    ../../../../../../Drivers/STM32N6xx_HAL_Driver/Src/: stm32n6xx_hal.c stm32n6xx_hal_adc.c stm32n6xx_hal_adc_ex.c stm32n6xx_hal_cacheaxi.c stm32n6xx_hal_cortex.c stm32n6xx_hal_dma.c stm32n6xx_hal_dma_ex.c stm32n6xx_hal_exti.c stm32n6xx_hal_gpio.c stm32n6xx_hal_i2c.c stm32n6xx_hal_i2c_ex.c stm32n6xx_hal_icache.c stm32n6xx_hal_mdf.c stm32n6xx_hal_pcd.c stm32n6xx_hal_pcd_ex.c stm32n6xx_hal_pwr.c stm32n6xx_hal_pwr_ex.c stm32n6xx_hal_rcc.c stm32n6xx_hal_rcc_ex.c stm32n6xx_hal_rif.c stm32n6xx_hal_sai.c stm32n6xx_hal_sai_ex.c stm32n6xx_hal_sd.c stm32n6xx_hal_sd_ex.c stm32n6xx_hal_tim.c stm32n6xx_hal_tim_ex.c stm32n6xx_ll_dma.c stm32n6xx_ll_sdmmc.c stm32n6xx_ll_usb.c
  group Middlewares/USBX/CoreSystem
    ../../../../../../Middlewares/ST/usbx/common/core/src/: ux_system_error_handler.c ux_system_initialize.c ux_system_tasks_run.c ux_system_uninitialize.c ux_utility_debug_callback_register.c ux_utility_debug_log.c ux_utility_delay_ms.c ux_utility_descriptor_pack.c ux_utility_descriptor_parse.c ux_utility_error_callback_register.c ux_utility_event_flags_create.c ux_utility_event_flags_delete.c ux_utility_event_flags_get.c ux_utility_event_flags_set.c ux_utility_long_get.c ux_utility_long_get_big_endian.c ux_utility_long_put.c ux_utility_long_put_big_endian.c ux_utility_memory_allocate.c ux_utility_memory_allocate_add_safe.c ux_utility_memory_allocate_mulc_safe.c ux_utility_memory_allocate_mulv_safe.c ux_utility_memory_byte_pool_create.c ux_utility_memory_byte_pool_search.c ux_utility_memory_compare.c ux_utility_memory_copy.c ux_utility_memory_free.c ux_utility_memory_free_block_best_get.c ux_utility_memory_set.c ux_utility_mutex_create.c ux_utility_mutex_delete.c ux_utility_mutex_off.c ux_utility_mutex_on.c ux_utility_pci_class_scan.c ux_utility_pci_read.c ux_utility_pci_write.c ux_utility_physical_address.c ux_utility_semaphore_create.c ux_utility_semaphore_delete.c ux_utility_semaphore_get.c ux_utility_semaphore_put.c ux_utility_set_interrupt_handler.c ux_utility_short_get.c ux_utility_short_get_big_endian.c ux_utility_short_put.c ux_utility_short_put_big_endian.c ux_utility_string_length_check.c ux_utility_string_length_get.c ux_utility_string_to_unicode.c ux_utility_timer_create.c ux_utility_timer_delete.c ux_utility_unicode_to_string.c ux_utility_virtual_address.c
  group Middlewares/USBX/Device Core Stack
    ../../../../../../Middlewares/ST/usbx/common/core/src/: ux_device_stack_alternate_setting_get.c ux_device_stack_alternate_setting_set.c ux_device_stack_class_register.c ux_device_stack_class_unregister.c ux_device_stack_clear_feature.c ux_device_stack_configuration_get.c ux_device_stack_configuration_set.c ux_device_stack_control_request_process.c ux_device_stack_descriptor_send.c ux_device_stack_disconnect.c ux_device_stack_endpoint_stall.c ux_device_stack_get_status.c ux_device_stack_host_wakeup.c ux_device_stack_initialize.c ux_device_stack_interface_delete.c ux_device_stack_interface_get.c ux_device_stack_interface_set.c ux_device_stack_interface_start.c ux_device_stack_microsoft_extension_register.c ux_device_stack_set_feature.c ux_device_stack_tasks_run.c ux_device_stack_transfer_abort.c ux_device_stack_transfer_all_request_abort.c ux_device_stack_transfer_request.c ux_device_stack_transfer_run.c ux_device_stack_uninitialize.c
  group Middlewares/USBX/UX Device Class AUDIO Core
    ../../../../../../Middlewares/ST/usbx/common/usbx_device_classes/src/: ux_device_class_audio10_control_process.c ux_device_class_audio20_control_process.c ux_device_class_audio_activate.c ux_device_class_audio_change.c ux_device_class_audio_control_request.c ux_device_class_audio_deactivate.c ux_device_class_audio_entry.c ux_device_class_audio_feedback_get.c ux_device_class_audio_feedback_set.c ux_device_class_audio_feedback_task_function.c ux_device_class_audio_frame_write.c ux_device_class_audio_initialize.c ux_device_class_audio_interrupt_send.c ux_device_class_audio_interrupt_task_function.c ux_device_class_audio_ioctl.c ux_device_class_audio_read_task_function.c ux_device_class_audio_sample_read16.c ux_device_class_audio_sample_read24.c ux_device_class_audio_sample_read32.c ux_device_class_audio_sample_read8.c ux_device_class_audio_speed_get.c ux_device_class_audio_stream_get.c ux_device_class_audio_tasks_run.c ux_device_class_audio_unitialize.c ux_device_class_audio_write_task_function.c
  group Middlewares/USBX/UX Device Class AUDIO Playback
    ../../../../../../Middlewares/ST/usbx/common/usbx_device_classes/src/: ux_device_class_audio_read_frame_free.c ux_device_class_audio_read_frame_get.c ux_device_class_audio_reception_start.c
  group Middlewares/USBX/UX Device Controllers
    ../../../../../../Middlewares/ST/usbx/common/usbx_stm32_device_controllers/: ux_dcd_stm32_callback.c ux_dcd_stm32_endpoint_create.c ux_dcd_stm32_endpoint_destroy.c ux_dcd_stm32_endpoint_reset.c ux_dcd_stm32_endpoint_stall.c ux_dcd_stm32_endpoint_status.c ux_dcd_stm32_frame_number_get.c ux_dcd_stm32_function.c ux_dcd_stm32_initialize.c ux_dcd_stm32_initialize_complete.c ux_dcd_stm32_interrupt_handler.c ux_dcd_stm32_transfer_abort.c ux_dcd_stm32_transfer_request.c ux_dcd_stm32_transfer_run.c ux_dcd_stm32_uninitialize.c

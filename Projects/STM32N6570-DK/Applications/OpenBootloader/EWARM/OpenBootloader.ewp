# IAR project OpenBootloader.ewp, settings and files
configuration STM32N6570-DK (ARM, debug)
  General.OGChipSelectEditMenu: STM32N6570-DK ST STM32N6570-DK
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 63
  General.FPU2: 7
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; USE_HAL_DRIVER; STM32N657xx; USE_USB_HS; USER_VECT_TAB_ADDRESS
  ICCARM.CCIncludePath2: ..\Core\Inc; ..\OpenBootloader\App; ..\OpenBootloader\Target; ..\USB_Device\App; ..\USB_Device\Target; ..\..\..\..\..\Middlewares\ST\OpenBootloader\Core; ..\..\..\..\..\Middlewares\ST\OpenBootloader\Util; ..\..\..\..\..\Middlewares\ST\OpenBootloader\Modules\Mem; ..\..\..\..\..\Middlewares\ST\OpenBootloader\Modules\USART; ..\..\..\..\..\Middlewares\ST\OpenBootloader\Modules\USB; ..\..\..\..\..\Middlewares\ST\OpenBootloader\STM32_USB_Device_Library\Class\DFU\Inc; ..\..\..\..\..\Middlewares\ST\OpenBootloader\STM32_USB_Device_Library\Core\Inc; ..\..\..\..\..\Drivers\CMSIS\Core\Include; ..\..\..\..\..\Drivers\STM32N6xx_HAL_Driver\Inc; ..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32N6xx\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: OpenBootloader_STM32N6570-DK.bin
  ILINK.IlinkOutputFile: OpenBootloader.out
  ILINK.IlinkIcfFile: stm32n657xx_axisram_s.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/Core
    ../Core/Src/: main.c stm32n6xx_hal_msp.c stm32n6xx_it.c
  group Application/EWARM
    ./: startup_stm32n657xx.s
  group Application/Openbootloader/App
    ../OpenBootloader/App/: app_openbootloader.c
  group Application/Openbootloader/Target
    ../OpenBootloader/Target/: common_interface.c external_memory_interface.c iwdg_interface.c otp_interface.c ram_interface.c usart_interface.c usb_interface.c
  group Application/USB_Device/App
    ../USB_Device/App/: usb_device.c usbd_desc.c usbd_dfu_if.c
  group Application/USB_Device/Target
    ../USB_Device/Target/: usbd_conf.c
  group Doc
    ../: README.md
  group Drivers/CMSIS
    ../Core/Src/: system_stm32n6xx_fsbl.c
  group Drivers/STM32N6xx_HAL_Driver
    ../../../../../Drivers/STM32N6xx_HAL_Driver/Src/: stm32n6xx_hal.c stm32n6xx_hal_bsec.c stm32n6xx_hal_cortex.c stm32n6xx_hal_gpio.c stm32n6xx_hal_hcd.c stm32n6xx_hal_iwdg.c stm32n6xx_hal_pcd.c stm32n6xx_hal_pcd_ex.c stm32n6xx_hal_pwr.c stm32n6xx_hal_pwr_ex.c stm32n6xx_hal_rcc.c stm32n6xx_hal_rcc_ex.c stm32n6xx_hal_usart.c stm32n6xx_hal_usart_ex.c stm32n6xx_ll_gpio.c stm32n6xx_ll_rcc.c stm32n6xx_ll_usart.c stm32n6xx_ll_usb.c
  group Middlewares/OpenBootloader/Core
    ../../../../../Middlewares/ST/OpenBootloader/Core/: openbl_core.c
  group Middlewares/OpenBootloader/Modules/MEM
    ../../../../../Middlewares/ST/OpenBootloader/Modules/Mem/: openbl_mem.c
  group Middlewares/OpenBootloader/Modules/USART
    ../../../../../Middlewares/ST/OpenBootloader/Modules/USART/: openbl_usart_cmd.c
  group Middlewares/OpenBootloader/Modules/USB
    ../../../../../Middlewares/ST/OpenBootloader/Modules/USB/: openbl_usb_cmd.c
  group Middlewares/OpenBootloader/USB_Device_Library
    ../../../../../Middlewares/ST/OpenBootloader/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../../../../../Middlewares/ST/OpenBootloader/STM32_USB_Device_Library/Class/DFU/Src/: usbd_dfu.c
  group Middlewares/OpenBootloader/Util
    ../../../../../Middlewares/ST/OpenBootloader/Util/: openbl_util.c

# Keil uVision project OpenBootloader.uvprojx, settings and files
target STM32N6570-DK (6210000::V6.21::ARMCLANG)
  device: STM32N657X0HxQ STMicroelectronics
  pack: Keil.STM32N6xx_DFP.1.0.0
  cpu: IRAM(0x341C0000-0x341FFFFF) IROM(0x34180400-0x341C03FF) CLOCK(8000000) FPU3(DFPU) CPUTYPE("Cortex-M55") ELITTLE TZ DSP
  output: OpenBootloader +hex
  AfterMake: fromelf #L --bincombined --output=$L@L.bin
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_FULL_LL_DRIVER,USE_HAL_DRIVER,STM32N657xx,USE_USB_HS,USER_VECT_TAB_ADDRESS
  c include: ../Core/Inc;../OpenBootloader/App;../OpenBootloader/Target;../USB_Device/App;../USB_Device/Target;../../../../../Middlewares/ST/OpenBootloader/Core;../../../../../Middlewares/ST/OpenBootloader/Util;../../../../../Middlewares/ST/OpenBootloader/Modules/Mem;../../../../../Middlewares/ST/OpenBootloader/Modules/USART;../../../../../Middlewares/ST/OpenBootloader/Modules/USB;../../../../../Middlewares/ST/OpenBootloader/STM32_USB_Device_Library/Class/DFU/Inc;../../../../../Middlewares/ST/OpenBootloader/STM32_USB_Device_Library/Core/Inc;../../../../../Drivers/CMSIS/Core/Include;../../../../../Drivers/STM32N6xx_HAL_Driver/Inc;../../../../../Drivers/CMSIS/Device/ST/STM32N6xx/Include
  memory RVCT4: ROM 0x34180400 size 0x19000
  memory RVCT9: RAM 0x34199400 size 0xa000
  scatter file: .\stm32n657xx_axisram2_fsbl.sct
  group Application/Core
    ../Core/Src/: main.c stm32n6xx_hal_msp.c stm32n6xx_it.c
  group Application/MDK-ARM
    ./: startup_stm32n657xx_fsbl.c
  group Application/Openbootloader/App
    ../OpenBootloader/App/: app_openbootloader.c
  group Application/Openbootloader/Target
    ../OpenBootloader/Target/: common_interface.c external_memory_interface.c iwdg_interface.c otp_interface.c ram_interface.c usart_interface.c usb_interface.c
  group Application/USB_Device/App
    ../USB_Device/App/: usb_device.c usbd_desc.c usbd_dfu_if.c
  group Application/USB_Device/Target
    ../USB_Device/Target/: usbd_conf.c
  group Doc
    ../: README.md
  group Drivers/CMSIS
    ../Core/Src/: system_stm32n6xx_fsbl.c
  group Drivers/STM32N6xx_HAL_Driver
    ../../../../../Drivers/STM32N6xx_HAL_Driver/Src/: stm32n6xx_hal.c stm32n6xx_hal_bsec.c stm32n6xx_hal_cortex.c stm32n6xx_hal_gpio.c stm32n6xx_hal_hcd.c stm32n6xx_hal_iwdg.c stm32n6xx_hal_pcd.c stm32n6xx_hal_pcd_ex.c stm32n6xx_hal_pwr.c stm32n6xx_hal_pwr_ex.c stm32n6xx_hal_rcc.c stm32n6xx_hal_rcc_ex.c stm32n6xx_hal_usart.c stm32n6xx_hal_usart_ex.c stm32n6xx_ll_gpio.c stm32n6xx_ll_rcc.c stm32n6xx_ll_usart.c stm32n6xx_ll_usb.c
  group Middlewares/OpenBootloader/Core
    ../../../../../Middlewares/ST/OpenBootloader/Core/: openbl_core.c
  group Middlewares/OpenBootloader/Modules/MEM
    ../../../../../Middlewares/ST/OpenBootloader/Modules/Mem/: openbl_mem.c
  group Middlewares/OpenBootloader/Modules/USART
    ../../../../../Middlewares/ST/OpenBootloader/Modules/USART/: openbl_usart_cmd.c
  group Middlewares/OpenBootloader/Modules/USB
    ../../../../../Middlewares/ST/OpenBootloader/Modules/USB/: openbl_usb_cmd.c
  group Middlewares/OpenBootloader/USB_Device_Library
    ../../../../../Middlewares/ST/OpenBootloader/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../../../../../Middlewares/ST/OpenBootloader/STM32_USB_Device_Library/Class/DFU/Src/: usbd_dfu.c
  group Middlewares/OpenBootloader/Util
    ../../../../../Middlewares/ST/OpenBootloader/Util/: openbl_util.c
software components: CMSIS:CORE 5.6.0

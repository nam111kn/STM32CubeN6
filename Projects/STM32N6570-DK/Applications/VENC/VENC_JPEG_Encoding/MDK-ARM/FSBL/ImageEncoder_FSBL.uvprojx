# Keil uVision project ImageEncoder_FSBL.uvprojx, settings and files
target ImageEncoder (6210000::V6.21::ARMCLANG)
  device: STM32N657X0HxQ STMicroelectronics
  pack: Keil.STM32N6xx_DFP.1.0.0
  cpu: IRAM(0x341C0000-0x341FFFFF) IROM(0x34180400-0x341C03FF) CLOCK(8000000) FPU3(DFPU) CPUTYPE("Cortex-M55") ELITTLE TZ DSP
  output: Project +hex
  AfterMake: fromelf #L --bincombined --output=$L@L.bin
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32N657xx
  c include: ../../FSBL/Inc;../../../../../../../Drivers/CMSIS/Include;../../../../../../../Drivers/CMSIS/Device/ST/STM32N6xx/Include;../../../../../../../Drivers/STM32N6xx_HAL_Driver/Inc;../../../../../../../Drivers/BSP/Components/Common;../../../../../../../Drivers/BSP/STM32N6570-DK;../../../../../../../Middlewares/ST/VideoEncoder_EWL;../../../../../../../Middlewares/Third_Party/VideoEncoder/source/common;../../../../../../../Middlewares/Third_Party/VideoEncoder/source/jpeg;../../../../../../../Middlewares/Third_Party/VideoEncoder/inc
  memory RVCT9: RAM 0x341c0000 size 0x40000
  scatter file: .\stm32n657xx_fsbl.sct
  group Code/src
    ../../FSBL/Src/: imageEncode.c main.c stm32n6xx_hal_msp.c stm32n6xx_it.c
  group Drivers/BSP/STM32N6570-DISCO
    ../../../../../../../Drivers/BSP/STM32N6570-DK/: stm32n6570_discovery.c
  group Drivers/CMSIS
    ../../FSBL/Src/: system_stm32n6xx_fsbl.c
  group Drivers/STM32N6xx_HAL_Driver
    ../../../../../../../Drivers/STM32N6xx_HAL_Driver/Src/: stm32n6xx_hal.c stm32n6xx_hal_cacheaxi.c stm32n6xx_hal_cortex.c stm32n6xx_hal_dma.c stm32n6xx_hal_dma_ex.c stm32n6xx_hal_gpio.c stm32n6xx_hal_pwr.c stm32n6xx_hal_pwr_ex.c stm32n6xx_hal_rcc.c stm32n6xx_hal_rcc_ex.c stm32n6xx_hal_rif.c stm32n6xx_hal_uart.c stm32n6xx_hal_uart_ex.c stm32n6xx_hal_usart.c stm32n6xx_ll_venc.c stm32n6xx_hal_exti.c
  group Middlewares/ST/VideoEncoder_EWL
    ../../../../../../../Middlewares/ST/VideoEncoder_EWL/: ewl_impl.c
  group Middlewares/Third_Party/VideoEncoder/common
    ../../../../../../../Middlewares/Third_Party/VideoEncoder/source/common/: encasiccontroller.c encasiccontroller_v2.c encInputLineBuffer.c encpreprocess.c encswhwregisters.c
  group Middlewares/Third_Party/VideoEncoder/jpeg
    ../../../../../../../Middlewares/Third_Party/VideoEncoder/source/jpeg/: EncJpeg.c EncJpegCodeFrame.c EncJpegInit.c EncJpegPutBits.c JpegEncApi.c
  group Application/MDK-ARM
    ../: startup_stm32n657xx_fsbl.c
software components: CMSIS:CORE 5.6.0

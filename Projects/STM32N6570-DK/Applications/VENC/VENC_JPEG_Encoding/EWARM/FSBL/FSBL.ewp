# IAR project FSBL.ewp, settings and files
configuration ImageEncoder (ARM, debug)
  General.OGChipSelectEditMenu: STM32N657X0 ST STM32N657X0
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 63
  General.FPU2: 7
  ICCARM.CCDefines: STM32N657xx
  ICCARM.CCDiagSuppress: Pe068,Pe111,Pe188
  ICCARM.CCIncludePath2: ..\..\FSBL\Inc; ../../../../../../../Drivers\CMSIS\Include; ../../../../../../../Drivers\CMSIS\Device\ST\STM32N6xx\Include; ../../../../../../../Drivers\STM32N6xx_HAL_Driver\Inc; ../../../../../../../Drivers\BSP\Components\Common; ../../../../../../../Drivers\BSP\STM32N6570-DK; ../../../../../../../Middlewares\ST\VideoEncoder_EWL; ../../../../../../../Middlewares\Third_Party\VideoEncoder\source\common; ../../../../../../../Middlewares\Third_Party\VideoEncoder\source\jpeg; ../../../../../../../Middlewares\Third_Party\VideoEncoder\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: FSBL.bin
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32n657xx.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Code/Inc
    ../../FSBL/Inc/: main.h stm32n6570_discovery_conf.h stm32n6xx_hal_conf.h stm32n6xx_it.h
  group Code/src
    ../../FSBL/Src/: imageEncode.c main.c stm32n6xx_hal_msp.c stm32n6xx_it.c
  group Drivers/BSP/STM32N6570-DISCO
    ../../../../../../../Drivers/BSP/STM32N6570-DK/: stm32n6570_discovery.c stm32n6570_discovery.h
  group Drivers/CMSIS
    ../: startup_stm32n657xx_fsbl.s
    ../../FSBL/Src/: system_stm32n6xx_fsbl.c
  group Drivers/STM32N6xx_HAL_Driver
    ../../../../../../../Drivers/STM32N6xx_HAL_Driver/Src/: stm32n6xx_hal.c stm32n6xx_hal_cacheaxi.c stm32n6xx_hal_cortex.c stm32n6xx_hal_dma.c stm32n6xx_hal_dma_ex.c stm32n6xx_hal_gpio.c stm32n6xx_hal_pwr.c stm32n6xx_hal_pwr_ex.c stm32n6xx_hal_rcc.c stm32n6xx_hal_rcc_ex.c stm32n6xx_hal_rif.c stm32n6xx_hal_uart.c stm32n6xx_hal_uart_ex.c stm32n6xx_hal_usart.c stm32n6xx_ll_venc.c
  group Middlewares/ST/VideoEncoder_EWL
    ../../../../../../../Middlewares/ST/VideoEncoder_EWL/: ewl_impl.c ewl_impl.h
  group Middlewares/Third_Party/VideoEncoder/common
    ../../../../../../../Middlewares/Third_Party/VideoEncoder/source/common/: encasiccontroller.c encasiccontroller.h encasiccontroller_v2.c enccfg.h encInputLineBuffer.c encpreprocess.c encpreprocess.h encswhwregisters.c
  group Middlewares/Third_Party/VideoEncoder/jpeg
    ../../../../../../../Middlewares/Third_Party/VideoEncoder/source/jpeg/: EncJpeg.c EncJpeg.h EncJpegCodeFrame.c EncJpegCodeFrame.h EncJpegCommon.h EncJpegDhtTables.h EncJpegInit.c EncJpegInit.h EncJpegInstance.h EncJpegMarkers.h EncJpegPutBits.c EncJpegPutBits.h EncJpegQuantTables.h JpegEncApi.c

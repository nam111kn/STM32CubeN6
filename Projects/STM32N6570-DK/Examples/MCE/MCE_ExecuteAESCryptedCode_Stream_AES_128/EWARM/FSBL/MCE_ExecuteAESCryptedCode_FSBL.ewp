# IAR project MCE_ExecuteAESCryptedCode_FSBL.ewp, settings and files
configuration MCE_ExecuteAESCryptedCode (ARM, debug)
  General.OGChipSelectEditMenu: STM32N657X0 ST STM32N657X0
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 63
  General.FPU2: 7
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32N657xx
  ICCARM.CCIncludePath2: ../../FSBL/Inc; ../../../../../../../Drivers/BSP/STM32N6570-DK; ../../../../../../../Drivers/STM32N6xx_HAL_Driver/Inc; ../../../../../../../Drivers/CMSIS/Device/ST/STM32N6xx/Include; ../../../../../../../Drivers/STM32N6xx_HAL_Driver/Inc/Legacy; ../../../../../../../Drivers/CMSIS/Include; ../../../../../../../Middlewares\ST\STM32_ExtMem_Manager
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: MCE_AESEncryptDecryptData_FSBL.bin
  ILINK.IlinkOutputFile: MCE_AESEncryptDecryptData_FSBL.out
  ILINK.IlinkIcfFile: stm32n657xx_axisram2_fsbl.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ../: startup_stm32n657xx_fsbl.s
  group Application/User/FSBL
    ../../FSBL/Src/: extmem.c main.c stm32n6xx_hal_msp.c stm32n6xx_it.c
  group Doc
    ../../: README.md
  group Drivers/BSP/STM32N6570-DK
    ../../../../../../../Drivers/BSP/STM32N6570-DK/: stm32n6570_discovery.c
  group Drivers/CMSIS
    ../../FSBL/Src/: system_stm32n6xx_fsbl.c
  group Drivers/STM32N6xx_HAL_Driver
    ../../../../../../../Drivers/STM32N6xx_HAL_Driver/Src/: stm32n6xx_hal.c stm32n6xx_hal_bsec.c stm32n6xx_hal_cortex.c stm32n6xx_hal_dma.c stm32n6xx_hal_dma_ex.c stm32n6xx_hal_exti.c stm32n6xx_hal_gpio.c stm32n6xx_hal_mce.c stm32n6xx_hal_pwr.c stm32n6xx_hal_pwr_ex.c stm32n6xx_hal_rcc.c stm32n6xx_hal_rcc_ex.c stm32n6xx_hal_xspi.c
  group Middlewares
    ../../FSBL/: stm32_extmem.c
  group Middlewares/NOR_SFDP
    ../../FSBL/nor_sfdp/: stm32_sfdp_data.c stm32_sfdp_driver.c
  group Middlewares/SAL
    ../../FSBL/sal/: stm32_sal_xspi.c

# IAR project Appli.ewp, settings and files
configuration JPEG_EncodingFromOSPI_DMA_Appli (ARM, debug)
  General.OGChipSelectEditMenu: STM32N6570-DK ST STM32N6570-DK
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 63
  General.FPU2: 7
  ICCARM.CCDefines: STM32N657xx; USE_FULL_ASSERT
  ICCARM.CCIncludePath2: ..\..\Appli\Inc; ..\..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32N6xx\Include; ..\..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\..\Drivers\STM32N6xx_HAL_Driver\Inc; ..\..\..\..\..\..\..\Drivers\BSP\STM32N6570-DK; ..\..\..\..\..\..\..\Utilities\JPEG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.bin
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32n657xx_XIP.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Drivers/BSP
    ../../../../../../../Drivers/BSP/STM32N6570-DK/: stm32n6570_discovery.c
  group Drivers/CMSIS
    ./: startup_stm32n657xx.s
    ../../Appli/Src/: system_stm32n6xx_s.c
  group Drivers/STM32N6xx_HAL_Driver
    ../../../../../../../Drivers/STM32N6xx_HAL_Driver/Src/: stm32n6xx_hal.c stm32n6xx_hal_cortex.c stm32n6xx_hal_dma.c stm32n6xx_hal_dma_ex.c stm32n6xx_hal_gpio.c stm32n6xx_hal_jpeg.c stm32n6xx_hal_pwr.c stm32n6xx_hal_pwr_ex.c stm32n6xx_hal_rif.c
  group Example
    ../../Appli/Src/: main.c stm32n6xx_hal_msp.c stm32n6xx_it.c
  group User
    ../../Appli/Src/: encode_dma.c Image_argb_8888.c Image_rgb_565.c Image_rgb_888.c
  group Utilities
    ../../../../../../../Utilities/JPEG/: jpeg_utils.c
